# Repository c8wf7gt28n-prog/Struthio (continued)

## KiCad design hardware/arc1-compact/R10_WORK/cad/ARC1_R10.kicad_pcb (continued)

Schematic: video.kicad_sch, ARC-1 Compact R10: D213 RGB888 + F133 I2S -> ADV7513 HDMI t…

Parts:
C129: 10pF; C_0402_1005Metric; not fitted
C130, C135, C139: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C131, C132, C133, C134, C136, C137, C138, C140, C141, C142, C144, C145, C146: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C143: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
FB3, FB4, FB5: ferrite 120R@100MHz; L_0603_1608Metric; MPN BLM18PG121SN1D (CANDIDATE)
J15: HDMI type-A; HDMI_A_Molex_208658-1001_Horizontal; MPN 2086581001
R80, R81, R82, R83: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
R84: 887R; R_0402_1005Metric
R85, R86, R87, R88, R89, R90, R92, R93, R96, R97: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R91: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168; not fitted
R94, R95: 2.2k; R_0402_1005Metric
TP53: LCD_DCLK; TestPoint_Pad_D1.0mm
TP54: HDMI_HPD; TestPoint_Pad_D1.0mm
TP55: HDMI_INT; TestPoint_Pad_D1.0mm
TP56: HDMI_5V; TestPoint_Pad_D1.0mm
TP57: I2S_BCLK; TestPoint_Pad_D1.0mm
TP58: I2S_LRCK; TestPoint_Pad_D1.0mm
U33: ADV7513BSWZ; LQFP-64-1EP_10x10mm_P0.5mm_EP5x5mm_ThermalVias; MPN ADV7513BSWZ
U34: TPD12S016; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TPD12S016PWR
X1: 12MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN 25 MHz 3.3 V CMOS XO 3225 (MPN TBD); not fitted

Connections:
1V8_ADV_A: C135.1, C136.1, C137.1, C138.1, FB4.2, U33.15 (AVDD), U33.19 (AVDD), U33.25 (AVDD)
1V8_ADV_D: C130.1, C131.1, C132.1, C133.1, C134.1, FB3.2, U33.1 (DVDD), U33.11 (DVDD), U33.31 (DVDD), U33.51 (DVDD)
1V8_ADV_P: C139.1, C140.1, C141.1, FB5.2, U33.12 (PVDD), U33.13 (BGVDD)
1V8_HDMI: FB3.1, FB4.1, FB5.1; also elsewhere on the board
3V3: C142.1, C143.1, C144.1, R93.2, R94.2, R95.2, R96.2, R97.2, U33.29 (DVDD_3V), U34.24 (VCCA), X1.1 (OE), X1.4 (VDD); also elsewhere on the board
ADV_CEC_CLK: R90.1, R91.2, U33.32 (CEC_CLK)
ADV_CEC_CLK_X: R91.1, X1.3 (OUT)
ADV_I2S1: R87.1, U33.6 (I2S1)
ADV_I2S2: R88.1, U33.7 (I2S2)
ADV_I2S3: R89.1, U33.8 (I2S3)
ADV_MCLK: R86.1, U33.4 (MCLK)
ADV_REXT: R84.1, U33.14 (R_EXT)
ADV_SPDIF: R85.1, U33.3 (SPDIF)
GND: C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, J15.2 (D2S), J15.5 (D1S), J15.8 (D0S), J15.11 (CKS), J15.17 (DDC_GND), J15.SH (SHIELD), R84.2, R85.2, R86.2, R87.2, R88.2, R89.2, R90.2, R92.2, U33.65 (EPAD_GND), U34.6 (GND), U34.14 (GND), U34.19 (GND), X1.2 (GND); also elsewhere on the board
HDMI_5V: C146.1, J15.18 (+5V), TP56.1, U34.13 (5V_OUT)
HDMI_CEC: J15.13 (CEC), U34.7 (CEC_B)
HDMI_CEC_A: U33.30 (CEC), U34.1 (CEC_A)
HDMI_DDC_SCL: U33.33 (DDCSCL), U34.2 (SCL_A)
HDMI_DDC_SDA: U33.34 (DDCSDA), U34.3 (SDA_A)
HDMI_HPD: TP54.1, U33.16 (HPD), U34.4 (HPD_A); also elsewhere on the board
HDMI_HPD_5V: J15.19 (HPD), U34.10 (HPD_B)
HDMI_I2C_SCL: R94.1, U33.35 (SCL); also elsewhere on the board
HDMI_I2C_SDA: R95.1, U33.36 (SDA); also elsewhere on the board
HDMI_INT: R93.1, TP55.1, U33.28 (INT); also elsewhere on the board
HDMI_PD: R92.1, U33.22 (PD); also elsewhere on the board
HDMI_SCL_5V: J15.15 (SCL), U34.8 (SCL_B)
HDMI_SDA_5V: J15.16 (SDA), U34.9 (SDA_B)
I2S_BCLK: TP57.1, U33.9 (SCLK); also elsewhere on the board
I2S_DOUT: U33.5 (I2S0); also elsewhere on the board
I2S_LRCK: TP58.1, U33.10 (LRCLK); also elsewhere on the board
LCD_D0: U33.62 (D0); also elsewhere on the board
LCD_D1: U33.61 (D1); also elsewhere on the board
LCD_D2: U33.60 (D2); also elsewhere on the board
LCD_D3: U33.59 (D3); also elsewhere on the board
LCD_D4: U33.58 (D4); also elsewhere on the board
LCD_D5: U33.57 (D5); also elsewhere on the board
LCD_D6: U33.56 (D6); also elsewhere on the board
LCD_D7: U33.55 (D7); also elsewhere on the board
LCD_D8: U33.54 (D8); also elsewhere on the board
LCD_D9: U33.52 (D9); also elsewhere on the board
LCD_D10: U33.50 (D10); also elsewhere on the board
LCD_D11: U33.49 (D11); also elsewhere on the board
LCD_D12: U33.48 (D12); also elsewhere on the board
LCD_D13: U33.47 (D13); also elsewhere on the board
LCD_D14: U33.46 (D14); also elsewhere on the board
LCD_D15: U33.45 (D15); also elsewhere on the board
LCD_D16: U33.44 (D16); also elsewhere on the board
LCD_D17: U33.43 (D17); also elsewhere on the board
LCD_D18: U33.42 (D18); also elsewhere on the board
LCD_D19: U33.41 (D19); also elsewhere on the board
LCD_D20: U33.40 (D20); also elsewhere on the board
LCD_D21: U33.39 (D21); also elsewhere on the board
LCD_D22: U33.38 (D22); also elsewhere on the board
LCD_D23: U33.37 (D23); also elsewhere on the board
LCD_DCLK: C129.1, R80.2, TP53.1, U33.53 (CLK)
LCD_DCLK_D: R80.1; also elsewhere on the board
LCD_DE: R83.2, U33.63 (DE)
LCD_DE_D: R83.1; also elsewhere on the board
LCD_HS: R81.2, U33.64 (HSYNC)
LCD_HS_D: R81.1; also elsewhere on the board
LCD_VS: R82.2, U33.2 (VSYNC)
LCD_VS_D: R82.1; also elsewhere on the board
TMDS_CK_N: J15.12 (CK-), U33.17 (TXC-), U34.15 (CLK-)
TMDS_CK_P: J15.10 (CK+), U33.18 (TXC+), U34.16 (CLK+)
TMDS_D0_N: J15.9 (D0-), U33.20 (TX0-), U34.17 (D0-)
TMDS_D0_P: J15.7 (D0+), U33.21 (TX0+), U34.18 (D0+)
TMDS_D1_N: J15.6 (D1-), U33.23 (TX1-), U34.20 (D1-)
TMDS_D1_P: J15.4 (D1+), U33.24 (TX1+), U34.21 (D1+)
TMDS_D2_N: J15.3 (D2-), U33.26 (TX2-), U34.22 (D2-)
TMDS_D2_P: J15.1 (D2+), U33.27 (TX2+), U34.23 (D2+)
TPD_CT_HPD: R97.1, U34.12 (CT_HPD)
TPD_LS_OE: R96.1, U34.5 (LS_OE)
VBUS_5V: C145.1, U34.11 (VCC5V); also elsewhere on the board

Notes on the sheet:
D213 RGB888 + F133 I2S -> ADV7513 HDMI transmitter (embedded audio) -> TPD12S016 -> HDMI-A Sheet generated from design.py; global labels carry every net.

Schematic: fpga45.kicad_sch, ARC-1 Compact R10: LFE5U-45F-6BG381C tile GPU: rails, slave…

Parts:
C147, C148, C149, C150, C151, C152, C153, C154, C155, C156, C157, C158, C159, C160, C161, C162, C163, C164, C165, C166, C170, C171, C172, C173, C175, C176, C177, C178, C179, C180, C181, C182, C183, C184, C185, C186, C187, C188, C189, C190, C191, C192, C200, C201, C202, C203: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C167, C168, C169, C174, C193, C194, C195, C196, C197, C198, C199: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
D6: 45F LED; LED_0603_1608Metric; MPN LED 0603 (MPN TBD)
J16: 45F JTAG; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN header 2x5 1.27 SMD
R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
R111, R112, R117, R118, R119: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R113, R114: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168; not fitted
R115, R132: 33R; R_0402_1005Metric; MPN 0402WGF330JTCE; LCSC C25105
R116, R126: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R120, R122, R123, R124, R125, R128, R129, R130, R131: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R121: 470R; R_0402_1005Metric
R127, R133: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
TP59: G_TXCK; TestPoint_Pad_D1.0mm
TP60: G_RXCK; TestPoint_Pad_D1.0mm
TP61: G_CLKIN; TestPoint_Pad_D1.0mm
TP62: FPGA45_DONE; TestPoint_Pad_D1.0mm
TP63: FPGA45_PROGRAMN; TestPoint_Pad_D1.0mm
TP64: FPGA45_INITN; TestPoint_Pad_D1.0mm
TP65: FPGA45_SCK; TestPoint_Pad_D1.0mm
TP66: F45_OSC_25M; TestPoint_Pad_D1.0mm
U35: LFE5U-45F-6BG381C; Lattice_caBGA-381_17x17mm_Layout20x20_P0.8mm; MPN LFE5U-45F-6BG381C
U36: iso FPGA45_SCK_B; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
U37: iso FPGA45_MOSI; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
U38: iso FPGA45_SS_N; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
X2: 125MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN 25 MHz 3.3 V CMOS XO 3225 (MPN TBD); not fitted
X3: 25MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN 25 MHz 3.3 V CMOS XO 3225 (MPN TBD)

Connections:
1V1_F45: C147.1, C148.1, C149.1, C150.1, C151.1, C152.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.1, C159.1, C160.1, C161.1, C162.1, C163.1, C164.1, C165.1, C166.1, C167.1, C168.1, C169.1, U35.H8 (VCC), U35.H9 (VCC), U35.H10 (VCC), U35.H11 (VCC), U35.H12 (VCC), U35.H13 (VCC), U35.J8 (VCC), U35.J13 (VCC), U35.K8 (VCC), U35.K13 (VCC), U35.L8 (VCC), U35.L13 (VCC), U35.M8 (VCC), U35.M13 (VCC), U35.N8 (VCC), U35.N9 (VCC), U35.N10 (VCC), U35.N11 (VCC), U35.N12 (VCC), U35.N13 (VCC); also elsewhere on the board
2V5_F45: C170.1, C171.1, C172.1, C173.1, C174.1, U35.F6 (VCCAUX), U35.F15 (VCCAUX), U35.P6 (VCCAUX), U35.P15 (VCCAUX); also elsewhere on the board
3V3: R116.2, X2.1 (OE), X2.4 (VDD); also elsewhere on the board
3V3_F45: C175.1, C176.1, C177.1, C178.1, C179.1, C180.1, C181.1, C182.1, C183.1, C184.1, C185.1, C186.1, C187.1, C188.1, C189.1, C190.1, C191.1, C192.1, C193.1, C194.1, C195.1, C196.1, C197.1, C198.1, C199.1, C200.1, C201.1, C202.1, C203.1, J16.1, R120.2, R122.2, R123.2, R124.2, R125.2, R126.2, R127.2, R129.2, R130.2, R131.2, U35.F9 (VCCIO0), U35.F10 (VCCIO0), U35.F11 (VCCIO1), U35.F12 (VCCIO1), U35.H6 (VCCIO7), U35.H7 (VCCIO7), U35.H14 (VCCIO2), U35.H15 (VCCIO2), U35.J6 (VCCIO7), U35.J15 (VCCIO2), U35.L6 (VCCIO6), U35.L7 (VCCIO6), U35.L14 (VCCIO3), U35.L15 (VCCIO3), U35.M6 (VCCIO6), U35.M15 (VCCIO3), U35.P9 (VCCIO8), U35.P10 (VCCIO8), U36.5 (VCC), U37.5 (VCC), U38.5 (VCC), X3.4 (VDD); also elsewhere on the board
F45_LED0: R133.1, U35.A7 (PT18A)
F45_LED0_R: D6.2 (A), R133.2
F45_OSC_25M: R132.2, TP66.1, U35.P3 (PL68C/LLC_GPLL0T_IN)
F45_OSC_25M_X: R132.1, X3.3 (OUT)
FPGA45_CFG0: R125.1, U35.U4 (CFG_0)
FPGA45_DONE: R123.1, TP62.1, U35.Y3 (DONE); also elsewhere on the board
FPGA45_HOLDN: R126.1, U35.R2 (PB15A/HOLDN)
FPGA45_INITN: R122.1, TP64.1, U35.V3 (INITN); also elsewhere on the board
FPGA45_MISO: R119.1, U35.V2 (PB11A/D1); also elsewhere on the board
FPGA45_MOSI: U35.W2 (PB11B/D0), U37.4 (Y)
FPGA45_MOSI_D: R118.1, U37.2 (A); also elsewhere on the board
FPGA45_PROGRAMN: J16.10, R120.1, R121.2, TP63.1, U35.W3 (PROGRAMN)
FPGA45_PROGRAMN_D: R121.1; also elsewhere on the board
FPGA45_SCK: R115.2, R127.1, TP65.1, U35.U3 (CCLK/MCLK)
FPGA45_SCK_B: R115.1, U36.4 (Y)
FPGA45_SCK_D: R117.1, U36.2 (A); also elsewhere on the board
FPGA45_SS_N: R124.1, U35.T2 (PB13A/SN), U38.4 (Y)
FPGA45_SS_N_D: R116.1, U38.2 (A); also elsewhere on the board
FPGA45_TCK: J16.4, R128.1, U35.T5 (TCK)
FPGA45_TDI: J16.8, R130.1, U35.R5 (TDI)
FPGA45_TDO: J16.6, R131.1, U35.V4 (TDO)
FPGA45_TMS: J16.2, R129.1, U35.U5 (TMS)
FPGA45_VCC_PG: X3.1 (OE); also elsewhere on the board
GND: C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, C169.2, C170.2, C171.2, C172.2, C173.2, C174.2, C175.2, C176.2, C177.2, C178.2, C179.2, C180.2, C181.2, C182.2, C183.2, C184.2, C185.2, C186.2, C187.2, C188.2, C189.2, C190.2, C191.2, C192.2, C193.2, C194.2, C195.2, C196.2, C197.2, C198.2, C199.2, C200.2, C201.2, C202.2, C203.2, D6.1 (K), J16.3, J16.5, J16.9, R111.2, R112.2, R117.2, R118.2, R119.2, R128.2, U35.B7 (GND), U35.B14 (GND), U35.C19 (GND), U35.D4 (GND), U35.F7 (GND), U35.F8 (GND), U35.F13 (GND), U35.F14 (GND), U35.G4 (GND), U35.G6 (GND), U35.G7 (GND), U35.G8 (GND), U35.G9 (GND), U35.G10 (GND), U35.G11 (GND), U35.G12 (GND), U35.G13 (GND), U35.G14 (GND), U35.G15 (GND), U35.G17 (GND), U35.H19 (GND), U35.J2 (GND), U35.J7 (GND), U35.J9 (GND), U35.J10 (GND), U35.J11 (GND), U35.J12 (GND), U35.J14 (GND), U35.K6 (GND), U35.K7 (GND), U35.K9 (GND), U35.K10 (GND), U35.K11 (GND), U35.K12 (GND), U35.K14 (GND), U35.K15 (GND), U35.L9 (GND), U35.L10 (GND), U35.L11 (GND), U35.L12 (GND), U35.M2 (GND), U35.M7 (GND), U35.M9 (GND), U35.M10 (GND), U35.M11 (GND), U35.M12 (GND), U35.M14 (GND), U35.M16 (GND), U35.N6 (GND), U35.N7 (GND), U35.N14 (GND), U35.N15 (GND), U35.P7 (GND), U35.P8 (GND), U35.P11 (GND), U35.P12 (GND), U35.P13 (GND), U35.P14 (GND), U35.R4 (CFG_2), U35.R19 (GND), U35.T4 (CFG_1), U35.T6 (GND), U35.T7 (GND), U35.T8 (GND), U35.T9 (GND), U35.T10 (GND), U35.T11 (GND), U35.T12 (GND), U35.T13 (GND), U35.T14 (GND), U35.T15 (GND), U35.U6 (GND), U35.U7 (GND), U35.U8 (GND), U35.U9 (GND), U35.U10 (GND), U35.U11 (GND), U35.U12 (GND), U35.U13 (GND), U35.U14 (GND), U35.U15 (GND), U35.V5 (GND), U35.V6 (GND), U35.V7 (GND), U35.V8 (GND), U35.V9 (GND), U35.V10 (GND), U35.V11 (GND), U35.V12 (GND), U35.V13 (GND), U35.V14 (GND), U35.V15 (GND), U35.V16 (GND), U35.V17 (GND), U35.V18 (GND), U35.V19 (GND), U35.V20 (GND), U35.W6 (GND), U35.W7 (GND), U35.W12 (GND), U35.W15 (GND), U35.W16 (GND), U35.W19 (GND), U35.W20 (GND), U35.Y5 (GND), U35.Y6 (GND), U35.Y7 (GND), U35.Y8 (GND), U35.Y11 (GND), U35.Y12 (GND), U35.Y14 (GND), U35.Y15 (GND), U35.Y16 (GND), U35.Y17 (GND), U35.Y19 (GND), U36.1 (~OE), U36.3 (GND), U37.1 (~OE), U37.3 (GND), U38.1 (~OE), U38.3 (GND), X2.2 (GND), X3.2 (GND); also elsewhere on the board
G_CLKIN: R110.2, R113.2, R114.2, TP61.1; also elsewhere on the board
G_CLKIN_F: R110.1, U35.B8 (PT15B)
G_CLKIN_OSC: R114.1, X2.3 (OUT)
G_RXCK: R104.2, R113.1, TP60.1; also elsewhere on the board
G_RXCK_F: R104.1, U35.C8 (PT15A)
G_RXCTL: R109.2, R112.1; also elsewhere on the board
G_RXCTL_F: R109.1, U35.C7 (PT11B)
G_RXD0: R105.2; also elsewhere on the board
G_RXD0_F: R105.1, U35.D9 (PT20A)
G_RXD1: R106.2; also elsewhere on the board
G_RXD1_F: R106.1, U35.E9 (PT20B)
G_RXD2: R107.2; also elsewhere on the board
G_RXD2_F: R107.1, U35.D8 (PT13B)
G_RXD3: R108.2; also elsewhere on the board
G_RXD3_F: R108.1, U35.E8 (PT13A)
G_TXCK: R98.2, TP59.1, U35.B11 (PT38A/PCLKT0_0)
G_TXCK_D: R98.1; also elsewhere on the board
G_TXCTL: R103.2, R111.1, U35.E10 (PT29B)
G_TXCTL_D: R103.1; also elsewhere on the board
G_TXD0: R99.2, U35.C10 (PT31B)
G_TXD0_D: R99.1; also elsewhere on the board
G_TXD1: R100.2, U35.B9 (PT31A)
G_TXD1_D: R100.1; also elsewhere on the board
G_TXD2: R101.2, U35.C9 (PT27A)
G_TXD2_D: R101.1; also elsewhere on the board
G_TXD3: R102.2, U35.D10 (PT29A)
G_TXD3_D: R102.1; also elsewhere on the board
SDR_A0: U35.P17 (PR41D); also elsewhere on the board
SDR_A1: U35.P18 (PR59D); also elsewhere on the board
SDR_A2: U35.P19 (PR59C); also elsewhere on the board
SDR_A3: U35.P20 (PR62A); also elsewhere on the board
SDR_A4: U35.R16 (PR44C); also elsewhere on the board
SDR_A5: U35.R17 (PR44D); also elsewhere on the board
SDR_A6: U35.R18 (PR65B); also elsewhere on the board
SDR_A7: U35.R20 (PR62B); also elsewhere on the board
SDR_A8: U35.T16 (PR53A); also elsewhere on the board
SDR_A9: U35.T18 (PR65D); also elsewhere on the board
SDR_A10: U35.T19 (PR65A); also elsewhere on the board
SDR_A11: U35.T20 (PR62C); also elsewhere on the board
SDR_A12: U35.U17 (PR68B); also elsewhere on the board
SDR_BA0: U35.N19 (PR59A); also elsewhere on the board
SDR_BA1: U35.N20 (PR59B); also elsewhere on the board
SDR_CAS_N: U35.N17 (PR44A); also elsewhere on the board
SDR_CKE: U35.M17 (PR41B); also elsewhere on the board
SDR_CLK_F: U35.L17 (PR38B); also elsewhere on the board
SDR_CS_N: U35.M18 (PR38D); also elsewhere on the board
SDR_DQ0: U35.C20 (PR23A); also elsewhere on the board
SDR_DQ1: U35.D18 (PR14A); also elsewhere on the board
SDR_DQ2: U35.D19 (PR23B); also elsewhere on the board
SDR_DQ3: U35.E16 (PR11C); also elsewhere on the board
SDR_DQ4: U35.E17 (PR14B); also elsewhere on the board
SDR_DQ5: U35.E18 (PR14C); also elsewhere on the board
SDR_DQ6: U35.E19 (PR23D); also elsewhere on the board
SDR_DQ7: U35.E20 (PR26A); also elsewhere on the board
SDR_DQ8: U35.F16 (PR11D); also elsewhere on the board
SDR_DQ9: U35.F17 (PR17A); also elsewhere on the board
SDR_DQ10: U35.F18 (PR14D); also elsewhere on the board
SDR_DQ11: U35.F19 (PR26B); also elsewhere on the board
SDR_DQ12: U35.F20 (PR26C); also elsewhere on the board
SDR_DQ13: U35.G16 (PR17C); also elsewhere on the board
SDR_DQ14: U35.G18 (PR17B); also elsewhere on the board
SDR_DQ15: U35.G20 (PR26D); also elsewhere on the board
SDR_DQM0: U35.H16 (PR17D); also elsewhere on the board
SDR_DQM1: U35.H17 (PR20B); also elsewhere on the board
SDR_RAS_N: U35.N16 (PR41A); also elsewhere on the board
SDR_WE_N: U35.N18 (PR41C); also elsewhere on the board

Notes on the sheet:
LFE5U-45F-6BG381C tile GPU: rails, slave-SPI config from the D213, JTAG, RGMII Sheet generated from design.py; global labels carry every net.

Schematic: sdram45.kicad_sch, ARC-1 Compact R10: AS4C16M16SA 32 MiB x16 SDR SDRAM, privat…

Parts:
C204, C205, C206, C207, C208, C209, C210: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C211, C212: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
R134: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
R135: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
TP67: SDR_CLK; TestPoint_Pad_D1.0mm
U39: AS4C16M16SA-6TIN; TSOP-II-54_22.2x10.16mm_P0.8mm; MPN AS4C16M16SA-6TIN

Connections:
3V3_F45: C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, U39.1 (VDD), U39.3 (VDDQ), U39.9 (VDDQ), U39.14 (VDD), U39.27 (VDD), U39.43 (VDDQ), U39.49 (VDDQ); also elsewhere on the board
GND: C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, R135.2, U39.6 (VSSQ), U39.12 (VSSQ), U39.28 (VSS), U39.41 (VSS), U39.46 (VSSQ), U39.52 (VSSQ), U39.54 (VSS); also elsewhere on the board
SDR_A0: U39.23 (A0); also elsewhere on the board
SDR_A1: U39.24 (A1); also elsewhere on the board
SDR_A2: U39.25 (A2); also elsewhere on the board
SDR_A3: U39.26 (A3); also elsewhere on the board
SDR_A4: U39.29 (A4); also elsewhere on the board
SDR_A5: U39.30 (A5); also elsewhere on the board
SDR_A6: U39.31 (A6); also elsewhere on the board
SDR_A7: U39.32 (A7); also elsewhere on the board
SDR_A8: U39.33 (A8); also elsewhere on the board
SDR_A9: U39.34 (A9); also elsewhere on the board
SDR_A10: U39.22 (A10); also elsewhere on the board
SDR_A11: U39.35 (A11); also elsewhere on the board
SDR_A12: U39.36 (A12); also elsewhere on the board
SDR_BA0: U39.20 (BA0); also elsewhere on the board
SDR_BA1: U39.21 (BA1); also elsewhere on the board
SDR_CAS_N: U39.17 (~CAS); also elsewhere on the board
SDR_CKE: R135.1, U39.37 (CKE); also elsewhere on the board
SDR_CLK: R134.2, TP67.1, U39.38 (CLK)
SDR_CLK_F: R134.1; also elsewhere on the board
SDR_CS_N: U39.19 (~CS); also elsewhere on the board
SDR_DQ0: U39.2 (DQ0); also elsewhere on the board
SDR_DQ1: U39.4 (DQ1); also elsewhere on the board
SDR_DQ2: U39.5 (DQ2); also elsewhere on the board
SDR_DQ3: U39.7 (DQ3); also elsewhere on the board
SDR_DQ4: U39.8 (DQ4); also elsewhere on the board
SDR_DQ5: U39.10 (DQ5); also elsewhere on the board
SDR_DQ6: U39.11 (DQ6); also elsewhere on the board
SDR_DQ7: U39.13 (DQ7); also elsewhere on the board
SDR_DQ8: U39.42 (DQ8); also elsewhere on the board
SDR_DQ9: U39.44 (DQ9); also elsewhere on the board
SDR_DQ10: U39.45 (DQ10); also elsewhere on the board
SDR_DQ11: U39.47 (DQ11); also elsewhere on the board
SDR_DQ12: U39.48 (DQ12); also elsewhere on the board
SDR_DQ13: U39.50 (DQ13); also elsewhere on the board
SDR_DQ14: U39.51 (DQ14); also elsewhere on the board
SDR_DQ15: U39.53 (DQ15); also elsewhere on the board
SDR_DQM0: U39.15 (LDQM); also elsewhere on the board
SDR_DQM1: U39.39 (UDQM); also elsewhere on the board
SDR_RAS_N: U39.18 (~RAS); also elsewhere on the board
SDR_WE_N: U39.16 (~WE); also elsewhere on the board

Notes on the sheet:
AS4C16M16SA 32 MiB x16 SDR SDRAM, private 45F memory, on 3V3_F45 Sheet generated from design.py; global labels carry every net.

Schematic: fpga12.kicad_sch, ARC-1 Compact R10: LFE5U-12F-6TG144C adaptive coprocessor: …

Parts:
C213, C214, C215, C216, C217, C218, C221, C222, C223, C224, C226, C227, C228, C229, C230, C231, C232, C233, C234, C238, C239, C240, C241, C242: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C219, C220, C225, C235, C236, C237: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
D7: 12F LED; LED_0603_1608Metric; MPN LED 0603 (MPN TBD)
J17: 12F JTAG; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN header 2x5 1.27 SMD
R136, R137, R138, R139, R140, R141, R142, R143, R144, R145, R146, R147: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
R148, R149, R153, R154: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R150, R167: 33R; R_0402_1005Metric; MPN 0402WGF330JTCE; LCSC C25105
R151, R152: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R155, R157, R158, R159, R160, R162, R163, R164, R165, R166: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R156: 470R; R_0402_1005Metric
R161, R168: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
TP68: ETH_TXCK; TestPoint_Pad_D1.0mm
TP69: ETH_RXCK; TestPoint_Pad_D1.0mm
TP70: FPGA12_DONE; TestPoint_Pad_D1.0mm
TP71: FPGA12_PROGRAMN; TestPoint_Pad_D1.0mm
TP72: FPGA12_INITN; TestPoint_Pad_D1.0mm
TP73: FPGA12_SCK; TestPoint_Pad_D1.0mm
U40: LFE5U-12F-6TG144C; TQFP-144_20x20mm_P0.5mm; MPN LFE5U-12F-6TG144C
U41: iso SCK; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
U42: iso MOSI; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
U43: iso SS; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
U44: iso MISO; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR
X4: 25MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN 25 MHz 3.3 V CMOS XO 3225 (MPN TBD)

Connections:
1V1_F12: C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, C220.1, U40.20 (VCC), U40.29 (VCC), U40.38 (VCC), U40.66 (VCC), U40.83 (VCC), U40.130 (VCC); also elsewhere on the board
2V5_F12: C221.1, C222.1, C223.1, C224.1, C225.1, U40.17 (VCCAUX), U40.53 (VCCAUX), U40.96 (VCCAUX), U40.132 (VCCAUX); also elsewhere on the board
3V3: C241.1, R151.2, R152.2, U44.5 (VCC); also elsewhere on the board
3V3_F12: C226.1, C227.1, C228.1, C229.1, C230.1, C231.1, C232.1, C233.1, C234.1, C235.1, C236.1, C237.1, C238.1, C239.1, C240.1, C242.1, J17.1, R155.2, R157.2, R158.2, R159.2, R160.2, R161.2, R163.2, R164.2, R165.2, R166.2, U40.9 (VCCIO7), U40.16 (VCCIO6), U40.36 (VCCIO6), U40.43 (VCCIO8), U40.70 (VCCIO3), U40.86 (VCCIO3), U40.100 (VCCIO2), U40.122 (VCCIO1), U40.137 (VCCIO0), U41.5 (VCC), U42.5 (VCC), U43.5 (VCC), X4.4 (VDD); also elsewhere on the board
ETH_RXCK: R142.2, TP69.1; also elsewhere on the board
ETH_RXCK_E: R142.1, U40.110 (PT67A)
ETH_RXCTL: R147.2, R149.1; also elsewhere on the board
ETH_RXCTL_E: R147.1, U40.115 (PT58B)
ETH_RXD0: R143.2; also elsewhere on the board
ETH_RXD0_E: R143.1, U40.111 (PT62B)
ETH_RXD1: R144.2; also elsewhere on the board
ETH_RXD1_E: R144.1, U40.112 (PT62A)
ETH_RXD2: R145.2; also elsewhere on the board
ETH_RXD2_E: R145.1, U40.113 (PT60B)
ETH_RXD3: R146.2; also elsewhere on the board
ETH_RXD3_E: R146.1, U40.114 (PT60A)
ETH_TXCK: R136.2, TP68.1, U40.128 (PT29A/PCLKT0_0)
ETH_TXCK_F: R136.1; also elsewhere on the board
ETH_TXCTL: R141.2, R148.1, U40.139 (PT9B)
ETH_TXCTL_F: R141.1; also elsewhere on the board
ETH_TXD0: R137.2, U40.133 (PT15B)
ETH_TXD0_F: R137.1; also elsewhere on the board
ETH_TXD1: R138.2, U40.134 (PT15A)
ETH_TXD1_F: R138.1; also elsewhere on the board
ETH_TXD2: R139.2, U40.135 (PT13B)
ETH_TXD2_F: R139.1; also elsewhere on the board
ETH_TXD3: R140.2, U40.136 (PT13A)
ETH_TXD3_F: R140.1; also elsewhere on the board
F12_LED0: R168.1, U40.121 (PT51A)
F12_LED0_R: D7.2 (A), R168.2
F12_OSC_25M: R167.2, U40.37 (PL47C/LLC_GPLL0T_IN)
F12_OSC_25M_X: R167.1, X4.3 (OUT)
FPGA12_BUS_EN_N: R151.1, U41.1 (~OE), U42.1 (~OE), U43.1 (~OE); also elsewhere on the board
FPGA12_CFG0: R160.1, U40.62 (CFG_0)
FPGA12_DONE: R158.1, TP70.1, U40.56 (DONE); also elsewhere on the board
FPGA12_INITN: R157.1, TP72.1, U40.55 (INITN); also elsewhere on the board
FPGA12_IRQ_N: R166.1, U40.124 (PT42B); also elsewhere on the board
FPGA12_MISO: R154.1, U40.46 (PB11A/D1), U44.2 (A)
FPGA12_MOSI: R153.1, U40.47 (PB11B/D0), U42.4 (Y)
FPGA12_PROGRAMN: J17.10, R155.1, R156.2, TP71.1, U40.57 (PROGRAMN)
FPGA12_PROGRAMN_F: R156.1; also elsewhere on the board
FPGA12_SCK: R150.2, R161.1, TP73.1, U40.54 (CCLK/MCLK)
FPGA12_SCK_B: R150.1, U41.4 (Y)
FPGA12_SS_N: R159.1, U40.48 (PB13A/SN), U43.4 (Y)
FPGA12_SS_N_F: R152.1, U43.2 (A), U44.1 (~OE); also elsewhere on the board
FPGA12_TCK: J17.4, R162.1, U40.63 (TCK)
FPGA12_TDI: J17.8, R164.1, U40.61 (TDI)
FPGA12_TDO: J17.6, R165.1, U40.60 (TDO)
FPGA12_TMS: J17.2, R163.1, U40.64 (TMS)
FPGA12_VCC_PG: X4.1 (OE); also elsewhere on the board
GND: C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, D7.1 (K), J17.3, J17.5, J17.9, R148.2, R149.2, R153.2, R154.2, R162.2, U40.8 (GND), U40.15 (GND), U40.21 (GND), U40.32 (GND), U40.42 (GND), U40.58 (CFG_2), U40.59 (CFG_1), U40.65 (GND), U40.75 (GND), U40.85 (GND), U40.87 (GND), U40.101 (GND), U40.123 (GND), U40.129 (GND), U40.131 (GND), U40.138 (GND), U41.3 (GND), U42.3 (GND), U43.3 (GND), U44.3 (GND), X4.2 (GND); also elsewhere on the board
PSRAM_CE_N: U40.72 (PR44C); also elsewhere on the board
PSRAM_SCLK_F: U40.73 (PR41D); also elsewhere on the board
PSRAM_SIO0: U40.74 (PR41C); also elsewhere on the board
PSRAM_SIO1: U40.76 (PR41B); also elsewhere on the board
PSRAM_SIO2: U40.77 (PR41A); also elsewhere on the board
PSRAM_SIO3: U40.78 (PR35D); also elsewhere on the board
SPI0_CLK: U41.2 (A); also elsewhere on the board
SPI0_MISO: U44.4 (Y); also elsewhere on the board
SPI0_MOSI: U42.2 (A); also elsewhere on the board

Notes on the sheet:
LFE5U-12F-6TG144C adaptive coprocessor: rails, slave-SPI config from the F133, JTAG, RGMII Sheet generated from design.py; global labels carry every net.

Schematic: psram12.kicad_sch, ARC-1 Compact R10: APS3204L 4 MiB QSPI PSRAM on the 12F (3V…

Parts:
C243: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C244: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
R169: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
R170: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R171, R172, R173, R174, R175: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
U45: APS3204L-3SQNA-SN; SOIC-8_3.9x4.9mm_P1.27mm; MPN APS3204L-3SQNA-SN

Connections:
3V3_F12: C243.1, C244.1, R170.2, U45.8 (VDD); also elsewhere on the board
GND: C243.2, C244.2, R171.2, R172.2, R173.2, R174.2, R175.2, U45.4 (VSS); also elsewhere on the board
PSRAM_CE_N: R170.1, U45.1 (~CE); also elsewhere on the board
PSRAM_SCLK: R169.2, R171.1, U45.6 (SCLK)
PSRAM_SCLK_F: R169.1; also elsewhere on the board
PSRAM_SIO0: R172.1, U45.5 (SI_SIO0); also elsewhere on the board
PSRAM_SIO1: R173.1, U45.2 (SO_SIO1); also elsewhere on the board
PSRAM_SIO2: R174.1, U45.3 (SIO2); also elsewhere on the board
PSRAM_SIO3: R175.1, U45.7 (SIO3); also elsewhere on the board

Notes on the sheet:
APS3204L 4 MiB QSPI PSRAM on the 12F (3V3_F12) Sheet generated from design.py; global labels carry every net.

Schematic: debug.kicad_sch, ARC-1 Compact R10: Internal: status LEDs, F133 UART0 fixtur…

Parts:
D8: STATUS; LED_0603_1608Metric; MPN LED 0603 (MPN TBD)
D9: ERROR; LED_0603_1608Metric; MPN LED 0603 (MPN TBD)
D10: 3V3; LED_0603_1608Metric; MPN LED 0603 (MPN TBD)
J18: F133 UART0; PinHeader_1x03_P2.54mm_Vertical; MPN header 1x3 2.54 (DNP-able); not fitted
R176, R177: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R178: 2k; R_0402_1005Metric

Connections:
3V3: R178.1; also elsewhere on the board
GND: D8.1 (K), D9.1 (K), D10.1 (K), J18.1; also elsewhere on the board
LED_3V3_R: D10.2 (A), R178.2
LED_ERROR: R177.1; also elsewhere on the board
LED_ERROR_R: D9.2 (A), R177.2
LED_STATUS: R176.1; also elsewhere on the board
LED_STATUS_R: D8.2 (A), R176.2
UART0_RX: J18.3; also elsewhere on the board
UART0_TX: J18.2; also elsewhere on the board

Notes on the sheet:
Internal: status LEDs, F133 UART0 fixture header Sheet generated from design.py; global labels carry every net.

Board: 6 copper layers, 596 parts (468 on the bottom side), 360 nets, no tracks yet.
